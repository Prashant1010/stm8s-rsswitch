# IAR project rcswitch-trans.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Users\prashant\Desktop\rcswitch-trans\stdlibraries\inc; C:\Users\prashant\Desktop\rcswitch-trans\lib\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: rcswitch-trans.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group lib/inc
    lib/inc/: delay.h rcswitch_trans.h uart.h
  group lib/src
    lib/src/: delay.c rcswitch_trans.c uart.c
  group stdlibraries/inc
    stdlibraries/inc/: stm8s.h stm8s_clk.h stm8s_conf.h stm8s_gpio.h stm8s_it.h stm8s_tim2.h stm8s_uart2.h
  group stdlibraries/src
    stdlibraries/src/: stm8s_clk.c stm8s_gpio.c stm8s_it.c stm8s_tim2.c stm8s_uart2.c
