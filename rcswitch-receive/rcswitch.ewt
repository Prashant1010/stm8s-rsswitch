<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>stdlibraries</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\stdlibraries\inc\stm8s.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\inc\stm8s_clk.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\inc\stm8s_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\inc\stm8s_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\inc\stm8s_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\inc\stm8s_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\inc\stm8s_itc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\inc\stm8s_tim2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\inc\stm8s_uart2.h</name>
      </file>
    </group>
    <group>
      <name>lib</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\lib\inc\buffer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lib\inc\micros.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lib\inc\rcswitch.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lib\inc\timer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lib\inc\uart.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\lib\src\buffer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lib\src\rcswitch.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lib\src\timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lib\src\uart.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\stdlibraries\src\stm8s_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\src\stm8s_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\src\stm8s_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\src\stm8s_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\src\stm8s_itc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\src\stm8s_tim2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\stdlibraries\src\stm8s_uart2.c</name>
      </file>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


